# IAR project PowerMonitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS_Startup; STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ./: main.cpp
  group CMSIS_Startup
    CMSIS_Startup/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c
