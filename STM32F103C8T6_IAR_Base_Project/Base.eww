<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PowerMonitor.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\STM32_Keil\Projects\PowerMonitor_IAR\IAR\PowerMonitor_IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
