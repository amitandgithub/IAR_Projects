# IAR project Gpio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\App\Inc; ..\Devices\inc; ..; ..\Test\inc; ..\Utils\inc; ..\STM32F1xx_HAL_Driver\Inc; ..\STM32F1xx_HAL_Driver\CMSIS\Device\ST\STM32F1xx\Include; ..\System; ..\STM32F1xx_HAL_Driver\CMSIS\Include; ..\Drivers\Gpio\inc; ..\CPP_FW\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../App/Src/: main.cpp
  group Drivers/Common
    ../CPP_FW/src/: Interrupt.cpp Peripheral.cpp
  group Drivers/Gpio
    ../Drivers/Gpio/src/: GpioInput.cpp GpioOutput.cpp
  group HAL
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_exti.c
  group IAR
    ../STM32F1xx_HAL_Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group System
    ../System/: stm32f1xx_it.c system_stm32f1xx.c
