<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Power_Monitor_2_Aug_2018.ewp</path>
    </project>
    <batchBuild />
</workspace>
