# IAR project Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USE_FULL_LL_DRIVER; HAL_DMA_MODULE_ENABLED; HAL_I2C_MODULE_ENABLED; HAL_SPI_MODULE_ENABLED; HAL_RTC_MODULE_ENABLED
  ICCARM.CCIncludePath2: ..\App\Inc; ..\Devices\inc; ..; ..\Test\inc; ..\Utils\inc; ..\STM32F1xx_HAL_Driver\Inc; ..\STM32F1xx_HAL_Driver\CMSIS\Device\ST\STM32F1xx\Include; ..\System; ..\STM32F1xx_HAL_Driver\CMSIS\Include; ..\Drivers\Gpio\inc; ..\CPP_FW\inc; ..\Drivers\I2C; ..\HW_Modules\inc; ..\Drivers\SPI; ..\Utils\inc; ..\Drivers\RTC; ..\SW_Modules\inc; ..\HW_Modules\SD\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Amit_Chaudhary\STM32\Projects\IAR\IAR_Projects\CPP_Drivers\Gpio\System\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../App/Src/: main.cpp
  group Drivers/Common
    ../CPP_FW/src/: Interrupt.cpp Peripheral.cpp
  group Drivers/Gpio
    ../Drivers/Gpio/src/: GpioInput.cpp GpioOutput.cpp
  group Drivers/I2C
    ../Drivers/I2C/: I2C_Base.cpp I2C_Master.cpp I2C_Slave.cpp
  group Drivers/RTC
    ../Drivers/RTC/: RTC_Module.cpp
  group Drivers/SPI
    ../Drivers/SPI/: SPI_Base.cpp SPI_DMA.cpp SPI_IT.cpp SPI_Poll.cpp
  group HAL
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_spi.c stm32f1xx_ll_exti.c
  group HW_Modules
    ../HW_Modules/: HwButton.cpp HwButtonIntr.cpp INA219.cpp Nokia5110LCD.cpp
  group HW_Modules/SD_Card
    ../HW_Modules/SD/src/: diskio.c fat_sd_spi.c ff.c SD.cpp
  group IAR
    ../STM32F1xx_HAL_Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group SW_Modules
    ../SW_Modules/: ControlScreen.cpp DisplayBuffer.cpp Screen.cpp UI.cpp
  group System
    ../System/: stm32f1xx_it.c system_stm32f1xx.c
  group Test
    ../Test/src/: Test.cpp
  group Utils
    ../Utils/src/: printf.c Utils.c
