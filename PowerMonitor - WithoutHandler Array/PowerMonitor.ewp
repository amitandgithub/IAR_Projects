# IAR project PowerMonitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS_Startup; STM32F10x_StdPeriph_Driver\inc; HAL\inc; App\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ./: main.cpp
    App/Src/: UIApp.cpp
  group HAL
    HAL/src/: ClockManager.cpp ControlScreen.cpp Gpio.cpp GpioInput.cpp GpioOutput.cpp HwButton.cpp HwButtonIntr.cpp I2c.cpp I2CDriver.cpp INA219.cpp InterruptManager.cpp Led.cpp Line.cpp Menu.cpp Nokia5110LCD.cpp Page.cpp PortManager.cpp Queue.cpp Screen.cpp SpiDriver.cpp SysTickTimer.cpp UI.cpp
  group Startup
    CMSIS_Startup/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
