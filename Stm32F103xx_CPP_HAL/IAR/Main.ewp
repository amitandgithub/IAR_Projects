# IAR project Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; HAL_DMA_MODULE_ENABLED; HAL_I2C_MODULE_ENABLED; HAL_SPI_MODULE_ENABLED; HAL_RTC_MODULE_ENABLED
  ICCARM.CCIncludePath2: ..\App\Inc; ..; ..\Test\inc; ..\Utils\inc; ..\System; ..\Utils\inc; ..\HAL\Common; ..\HAL\Drivers\Gpio; ..\STM32F1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Amit_Chaudhary\STM32\Projects\IAR\IAR_Projects\CPP_Drivers\Gpio\System\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../App/Src/: main.cpp
  group HAL/Common
    ../HAL/Common/: CPP_HAL.cpp
  group HAL/Drivers/Gpio
    ../HAL/Drivers/Gpio/: Gpio.cpp GpioOutput.cpp
  group IAR
    ../STM32F1xx_HAL_Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Peripherals
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
  group System
    ../System/: stm32f1xx_it.c system_stm32f1xx.c
  group Test
    ../Test/src/: Test.cpp
  group Utils
    ../Utils/src/: printf.c Utils.c
